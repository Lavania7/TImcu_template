# Keil uVision project empty_driverlib_src_LP_MSPM0G3507_nortos_keil.uvprojx, settings and files
target empty_driverlib_src_LP_MSPM0G3507_nortos_keil (6220000::V6.22::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: empty_driverlib_src_LP_MSPM0G3507_nortos_keil +hex
  BeforeMake: cmd.exe /C "$P../tools/keil/syscfg.bat '$P' empty.syscfg"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\ti_template;..\Core\Inc;..\Drivers;..\Drivers\ti;..\Drivers\third_party\CMSIS\Core\Include;..\App\Inc;..\Bsp\Inc;..\Drv\oled;..\Lib\font
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x8000
  memory RVCT7: RAM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: ./mspm0g3507.sct
  link misc: ../Drivers/ti/driverlib/lib/keil/m0p/mspm0g1x0x_g3x0x/driverlib.a
  group Source
    ../Drivers/ti/driverlib/: dl_adc12.h dl_aes.h dl_aesadv.h dl_common.h dl_comp.h dl_crc.h dl_crcp.h dl_dac12.h dl_dma.h dl_flashctl.h dl_gpamp.h dl_gpio.h dl_i2c.h dl_iwdt.h dl_keystorectl.h dl_lcd.h dl_lfss.h dl_mathacl.h dl_mcan.h dl_opa.h dl_rtc.h dl_rtc_a.h dl_rtc_b.h dl_rtc_common.h dl_scratchpad.h dl_spi.h dl_tamperio.h dl_timer.h dl_timera.h dl_timerg.h dl_trng.h dl_uart.h dl_uart_extend.h dl_uart_main.h dl_vref.h dl_wwdt.h driverlib.h dl_adc12.c dl_aes.c dl_aesadv.c dl_common.c dl_comp.c dl_crc.c dl_crcp.c dl_dac12.c dl_dma.c dl_flashctl.c dl_gpamp.c dl_gpio.c dl_i2c.c dl_iwdt.c dl_keystorectl.c dl_lcd.c dl_lfss.c dl_mathacl.c dl_mcan.c dl_opa.c dl_rtc.c dl_rtc_a.c dl_rtc_b.c dl_rtc_common.c dl_scratchpad.c dl_spi.c dl_tamperio.c dl_timer.c dl_timera.c dl_timerg.c dl_trng.c dl_uart.c dl_vref.c dl_wwdt.c
    ../Drivers/ti/driverlib/m0p/: dl_core.h dl_factoryregion.h dl_interrupt.h dl_sysctl.h dl_systick.h dl_factoryregion.c dl_interrupt.c
    ../Drivers/ti/driverlib/m0p/sysctl/: dl_sysctl_mspm0c1105_c1106.h dl_sysctl_mspm0c110x.h dl_sysctl_mspm0g1x0x_g3x0x.h dl_sysctl_mspm0gx51x.h dl_sysctl_mspm0h321x.h dl_sysctl_mspm0l111x.h dl_sysctl_mspm0l11xx_l13xx.h dl_sysctl_mspm0l122x_l222x.h dl_sysctl_mspm0c1105_c1106.c dl_sysctl_mspm0c110x.c dl_sysctl_mspm0g1x0x_g3x0x.c dl_sysctl_mspm0gx51x.c dl_sysctl_mspm0h321x.c dl_sysctl_mspm0l111x.c dl_sysctl_mspm0l11xx_l13xx.c dl_sysctl_mspm0l122x_l222x.c
    ../: empty.syscfg ti_msp_dl_config.h ti_msp_dl_config.c
    ./: startup_mspm0g350x_uvision.s
  group Core
    ../Core/Src/: main.c gpio.c tim.c i2c.c
  group App
    ../App/Src/: app.c
  group Bsp
    ../Bsp/Src/: bsp_tim.c bsp_gpio.c bsp_i2c.c
  group Drv
    ../Drv/oled/: oled.c
  group Lib
    ../Lib/font/: font.c
